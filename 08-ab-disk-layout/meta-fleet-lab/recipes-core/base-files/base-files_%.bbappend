# The greeting shown on the console before login (issue) and after an SSH
# login (motd).
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
